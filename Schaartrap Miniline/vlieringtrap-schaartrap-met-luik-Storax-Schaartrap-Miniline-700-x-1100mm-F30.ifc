Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 7b25f201-82f4-42cd-8093-51b570e58ff1.ifc
Time: 2026-08-11T16:09:29
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Miniline 700 x 1100mm F30
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAAKkm3RUGAAAADesCAAWxXwAAPHsBAHQGAACZ6wIACuwCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIA6-wCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAND7AAAFa98AAGQwAADGpwAAo60AAMv4AAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAKkm3RUGAAAADesCAAWxXwAAPHsBAHQGAACZ6wIACuwCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIA6-wCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAND7AAAFa98AAGQwAADGpwAAo60AAMv4AAAAAA)); STABU2: 32.32.11; lengte: 1080 mm; inbouwhoogte: 220 mm; inbouwlengte: 1100 mm; luchtdoorlatendheid klasse: 4; U-waarde: 0,92 w/m²·k; breedte: 680 mm; max. belasting: 150 kg; NAA.K.T: samengesteld_product_generiek; bediening: handmatig; theoretische levensduur: 50; serie: Schaartrap Miniline; inbouwbreedte: 700 mm; merk: Storax; beweegbaar: True; brandwerendheid EI2: 30 mm; omranding: spaanplaat; luik: hout; trap: schaarladder Storax - Schaarladder 280mm
