Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: cc79f8b2-2c8d-4652-9e65-246cd62e4696.ifc
Time: 2026-08-11T16:13:13
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Miniline 700 x 1200mm F60
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAAKlm2hUGAAAADesCAAWxXwAAPHsBAHQGAACZ6wIASusCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIA6-wCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAND7AAAFa98AAGQwAADGpwAAo60AAMv4AAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAKlm2hUGAAAADesCAAWxXwAAPHsBAHQGAACZ6wIASusCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIA6-wCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAND7AAAFa98AAGQwAADGpwAAo60AAMv4AAAAAA)); uitvoering: brandwerendheid EI2-60; STABU2: 32.32.11; lengte: 1180 mm; inbouwhoogte: 220 mm; inbouwlengte: 1200 mm; luchtdoorlatendheid klasse: 4; U-waarde: 0,92 w/m²·k; breedte: 680 mm; max. belasting: 150 kg; NAA.K.T: samengesteld_product_generiek; bediening: handmatig; theoretische levensduur: 50; serie: Schaartrap Miniline; inbouwbreedte: 700 mm; merk: Storax; beweegbaar: True; brandwerendheid EI2: 60 mm; omranding: spaanplaat; luik: hout; trap: schaarladder Storax - Schaarladder 280mm
