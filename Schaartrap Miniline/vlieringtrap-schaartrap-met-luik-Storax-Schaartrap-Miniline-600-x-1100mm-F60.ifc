Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 00401027-3364-40f6-a7f5-0f1c62e7111f.ifc
Time: 2026-08-11T16:06:48
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Miniline 600 x 1100mm F60
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAAKkx3RUGAAAADesCAAWxXwAAPHsBAHQGAACZ6wIAHewCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIA6-wCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAND7AAAFa98AAGQwAADGpwAAo60AAMv4AAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAKkx3RUGAAAADesCAAWxXwAAPHsBAHQGAACZ6wIAHewCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAAkVgAAAVpuQAAZDAAAManAACjrQAAvyUAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIA6-wCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAND7AAAFa98AAGQwAADGpwAAo60AAMv4AAAAAA)); uitvoering: brandwerendheid EI2-60; STABU2: 32.32.11; lengte: 1080 mm; inbouwhoogte: 220 mm; inbouwlengte: 1100 mm; luchtdoorlatendheid klasse: 4; U-waarde: 0,92 w/m²·k; breedte: 580 mm; max. belasting: 150 kg; NAA.K.T: samengesteld_product_generiek; bediening: handmatig; theoretische levensduur: 50; serie: Schaartrap Miniline; inbouwbreedte: 600 mm; merk: Storax; beweegbaar: True; brandwerendheid EI2: 60 mm; omranding: spaanplaat; luik: hout; trap: schaarladder Storax - Schaarladder 280mm
